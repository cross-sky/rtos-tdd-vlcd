# Keil uVision project rtos-tdd.uvproj, settings and files
target rtos-tdd (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: rtos-tdd +hex
  c flags: Optim=3 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c misc: --diag_suppress=870
  c include: ..\fwlib\CMSIS;..\fwlib\STM32F10x_StdPeriph_Driver\inc;..\user;..\user\bsp;..\user\bsp\inc;..\freertos\include;..\freertos\portable\RVDS\ARM_CM3;..\user\task\inc;..\user\hal\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ../user/: main.c FreeRTOSConfig.h includes.h
    ../user/task/src/: task_button.c
  group bsp
    ../user/: bsp.c SysInfoTest.c
    ../user/bsp/: stm32f10x_assert.c stm32f10x_it.c
    ../user/bsp/src/: bsp_led.c bsp_st7587.c BSP_gui.c bsp_button.c
  group fwlib
    ../fwlib/STM32F10x_StdPeriph_Driver/: STM32-keil.lib
  group cmsis
    ../fwlib/CMSIS/: core_cm3.c
    ../fwlib/CMSIS/startup/: startup_stm32f10x_md.s
    ../user/bsp/: system_stm32f10x.c
  group freertos
    ../freertos/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../freertos/portable/RVDS/ARM_CM3/: port.c portmacro.h
    ../freertos/portable/MemMang/: heap_4.c
  group hw
    ../user/hal/src/: hal_button.c hal_queue.c
